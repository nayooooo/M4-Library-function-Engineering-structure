# Keil uVision project Template.uvprojx, settings and files
target FLASH (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\inc;..\Fwlib\inc;..\System\sys;..\System\delay;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/Startup/: startup_stm32f401xx.s
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c
  group FWLIB
    ../Fwlib/src/: misc.c
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
  group USER
    ../User/: stm32f4xx_it.c main.c
